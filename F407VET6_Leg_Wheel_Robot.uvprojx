# Keil uVision project F407VET6_Leg_Wheel_Robot.uvprojx, settings and files
target F407VET6_Leg_Wheel_Robot (6210000::V6.21::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: F407VET6_Leg_Wheel_Robot +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/CMSIS/DSP/Include;../application/Algorithm/EKF;../application/Algorithm/function;../application/Algorithm/kalman;../application/Algorithm/mahony;../application/Algorithm/PID;../application/Algorithm/VMC;../application/APP;../application/Bsp;../application/Devices/BMI088;../application/Devices/DM_Motor;../application/Devices/BM_Motor;../application/Devices/RM_Motor;../application/Lib
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Bsp
    ../application/Bsp/: bsp_dwt.c usart_rc_dbus.c can_receive.c
  group Algorithm
    ../application/Algorithm/function/: function.c
    ../application/Algorithm/mahony/: mahony_filter.c
    ../application/Algorithm/PID/: pid.c
    ../application/Algorithm/VMC/: VMC_calc.c
    ../application/Algorithm/kalman/: kalman_filter.c
  group APP
    ../application/APP/: INS_task.c balance_chair_task.c observe_task.c Driver_task.c
  group Devices
    ../application/Devices/BMI088/: BMI088Middleware.c BMI088driver.c
    ../application/Devices/BM_Motor/: BM_Ctrl.c
  group DSP
    ../Drivers/CMSIS/DSP/Lib/ARM/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 5.6.0
